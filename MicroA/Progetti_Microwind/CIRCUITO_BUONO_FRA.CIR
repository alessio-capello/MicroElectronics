CIRCUIT F:\CONTROLLO VERSIONE\MICRO\MicroA\Progetti_Microwind\CIRCUITO_BUONO_FRA.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
Vb0 18 0 PULSE(0.00 1.20 0.98N 0.02N 0.02N 0.98N 2.00N)
Va0 19 0 PULSE(0.00 1.20 0.48N 0.02N 0.02N 0.48N 1.00N)
Vclock 20 0 PULSE(0.00 1.20 0.23N 0.02N 0.02N 0.23N 0.50N)
Vc0 21 0 PULSE(0.00 1.20 1.96N 0.02N 0.02N 1.96N 3.96N)
*
* List of nodes
* "SUM" corresponds to n°4
* "CARRY" corresponds to n°5
* "VG3" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* "N9" corresponds to n°9
* "b0" corresponds to n°18
* "a0" corresponds to n°19
* "clock" corresponds to n°20
* "c0" corresponds to n°21
*
* MOS devices
MN1 12 20 0 0 N1  W= 0.48U L= 0.12U
MN2 6 19 13 0 N1  W= 0.48U L= 0.12U
MN3 13 18 6 0 N1  W= 0.48U L= 0.12U
MN4 6 21 13 0 N1  W= 0.48U L= 0.12U
MN5 13 7 12 0 N1  W= 0.48U L= 0.12U
MN6 5 7 11 0 N1  W= 1.56U L= 0.12U
MN7 11 20 0 0 N1  W= 1.56U L= 0.12U
MN8 0 20 10 0 N1  W= 1.68U L= 0.12U
MN9 10 6 4 0 N1  W= 1.68U L= 0.12U
MN10 14 21 12 0 N1  W= 0.48U L= 0.12U
MN11 15 18 14 0 N1  W= 0.48U L= 0.12U
MN12 6 19 15 0 N1  W= 0.48U L= 0.12U
MN13 16 19 7 0 N1  W= 0.24U L= 0.12U
MN14 0 18 16 0 N1  W= 0.24U L= 0.12U
MN15 17 18 0 0 N1  W= 0.24U L= 0.12U
MN16 0 19 17 0 N1  W= 0.24U L= 0.12U
MN17 7 21 17 0 N1  W= 0.24U L= 0.12U
MP1 4 6 1 1 P1  W= 4.32U L= 0.12U
MP2 5 7 1 1 P1  W= 4.32U L= 0.12U
MP3 6 20 1 1 P1  W= 1.08U L= 0.12U
MP4 8 19 7 1 P1  W= 0.36U L= 0.12U
MP5 1 18 8 1 P1  W= 0.36U L= 0.12U
MP6 9 18 1 1 P1  W= 0.36U L= 0.12U
MP7 1 19 9 1 P1  W= 0.36U L= 0.12U
MP8 7 21 9 1 P1  W= 0.36U L= 0.12U
*
C2 1 0 10.213fF
C4 4 0  1.644fF
C5 5 0  1.526fF
C6 6 0  1.852fF
C7 7 0  1.517fF
C8 8 0  0.073fF
C9 9 0  0.322fF
C10 10 0  0.292fF
C11 11 0  0.272fF
C12 12 0  0.509fF
C13 13 0  0.401fF
C14 14 0  0.096fF
C15 15 0  0.096fF
C16 16 0  0.057fF
C17 17 0  0.244fF
C18 18 0  1.414fF
C19 19 0  1.302fF
C20 20 0  1.512fF
C21 21 0  1.256fF
*
* Extra RLC
*
Cadd1 5 0 0.1pF
Cadd2 4 0 0.1pF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.TRAN 0.30PS 10.00N
.PROBE
.END
