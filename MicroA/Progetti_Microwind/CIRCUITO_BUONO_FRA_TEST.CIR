CIRCUIT F:\CONTROLLO VERSIONE\MICRO\MicroA\Progetti_Microwind\CIRCUITO_BUONO_FRA_TEST.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
Vc0 18 0 PULSE(0.00 1.20 2.50N 0.02N 0.02N 1.98N 4.00N)
Vclock 19 0 PULSE(0.00 1.20 0.23N 0.02N 0.02N 0.23N 0.50N)
Va0 20 0 PULSE(0.00 1.20 0.50N 0.02N 0.02N 0.48N 1.00N)
Vb0 21 0 PULSE(0.00 1.20 1.50N 0.02N 0.02N 0.98N 2.00N)
*
* List of nodes
* "SUM" corresponds to n°4
* "CARRY" corresponds to n°5
* "VgSum" corresponds to n°6
* "VgCarry" corresponds to n°7
* "N8" corresponds to n°8
* "N9" corresponds to n°9
* "c0" corresponds to n°18
* "clock" corresponds to n°19
* "a0" corresponds to n°20
* "b0" corresponds to n°21
*
* MOS devices
MN1 12 19 0 0 N1  W= 0.72U L= 0.12U
MN2 6 20 13 0 N1  W= 0.72U L= 0.12U
MN3 13 21 6 0 N1  W= 0.72U L= 0.12U
MN4 6 18 13 0 N1  W= 0.72U L= 0.12U
MN5 13 7 12 0 N1  W= 0.72U L= 0.12U
MN6 0 19 11 0 N1  W= 2.52U L= 0.12U
MN7 11 7 5 0 N1  W= 2.52U L= 0.12U
MN8 0 19 10 0 N1  W= 2.52U L= 0.12U
MN9 10 6 4 0 N1  W= 2.52U L= 0.12U
MN10 14 18 12 0 N1  W= 0.72U L= 0.12U
MN11 15 21 14 0 N1  W= 0.72U L= 0.12U
MN12 6 20 15 0 N1  W= 0.72U L= 0.12U
MN13 16 20 7 0 N1  W= 0.48U L= 0.12U
MN14 0 21 16 0 N1  W= 0.48U L= 0.12U
MN15 17 21 0 0 N1  W= 0.48U L= 0.12U
MN16 0 20 17 0 N1  W= 0.48U L= 0.12U
MN17 7 18 17 0 N1  W= 0.48U L= 0.12U
MP1 4 6 1 1 P1  W= 4.32U L= 0.12U
MP2 5 7 1 1 P1  W= 4.32U L= 0.12U
MP3 6 19 1 1 P1  W= 1.08U L= 0.12U
MP4 8 20 7 1 P1  W= 0.72U L= 0.12U
MP5 1 21 8 1 P1  W= 0.72U L= 0.12U
MP6 9 21 1 1 P1  W= 0.72U L= 0.12U
MP7 1 20 9 1 P1  W= 0.72U L= 0.12U
MP8 7 18 9 1 P1  W= 0.72U L= 0.12U
*
C2 1 0  9.816fF
C4 4 0  1.812fF
C5 5 0  1.812fF
C6 6 0  2.293fF
C7 7 0  1.742fF
C8 8 0  0.129fF
C9 9 0  0.577fF
C10 10 0  0.429fF
C11 11 0  0.429fF
C12 12 0  0.624fF
C13 13 0  0.533fF
C14 14 0  0.135fF
C15 15 0  0.135fF
C16 16 0  0.096fF
C17 17 0  0.371fF
C18 18 0  1.400fF
C19 19 0  1.590fF
C20 20 0  1.371fF
C21 21 0  1.555fF
*
* Extra RLC
*
Cadd1 5 0 0.1pF
Cadd2 4 0 0.1pF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.TRAN 0.30PS 10.00N
.PROBE
.END
