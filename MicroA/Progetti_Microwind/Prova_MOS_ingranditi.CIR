CIRCUIT F:\CONTROLLO VERSIONE\MICRO\MicroA\Progetti_Microwind\Prova_Pista_Aereoporto.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
Va0 18 0 PULSE(0.00 1.20 0.48N 0.02N 0.02N 0.48N 1.00N)
Vb0 19 0 PULSE(0.00 1.20 0.98N 0.02N 0.04N 0.97N 2.01N)
Vc0 20 0 PULSE(0.00 1.20 1.97N 0.03N 0.02N 1.98N 4.00N)
Vclock 21 0 PULSE(0.00 1.20 0.23N 0.02N 0.02N 0.23N 0.50N)
*
* List of nodes
* "SUM" corresponds to n°3
* "CARRY" corresponds to n°5
* "VG3" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* "N9" corresponds to n°9
* "a0" corresponds to n°18
* "b0" corresponds to n°19
* "c0" corresponds to n°20
* "clock" corresponds to n°21
*
* MOS devices
MN1 13 19 6 0 N1  W= 0.36U L= 0.12U
MN2 15 19 14 0 N1  W= 0.36U L= 0.12U
MN3 14 20 6 0 N1  W= 0.36U L= 0.12U
MN4 6 20 13 0 N1  W= 0.36U L= 0.12U
MN5 13 7 12 0 N1  W= 0.36U L= 0.12U
MN6 0 21 11 0 N1  W= 1.44U L= 0.12U
MN7 11 7 5 0 N1  W= 1.44U L= 0.12U
MN8 0 21 10 0 N1  W= 1.44U L= 0.12U
MN9 10 6 3 0 N1  W= 1.44U L= 0.12U
MN10 12 18 15 0 N1  W= 0.36U L= 0.12U
MN11 6 18 13 0 N1  W= 0.36U L= 0.12U
MN12 0 21 12 0 N1  W= 0.36U L= 0.12U
MN13 16 18 7 0 N1  W= 0.24U L= 0.12U
MN14 0 19 16 0 N1  W= 0.24U L= 0.12U
MN15 17 19 0 0 N1  W= 0.24U L= 0.12U
MN16 0 18 17 0 N1  W= 0.24U L= 0.12U
MN17 7 20 17 0 N1  W= 0.24U L= 0.12U
MP1 3 6 1 1 P1  W= 4.32U L= 0.12U
MP2 5 7 1 1 P1  W= 4.32U L= 0.12U
MP3 6 21 1 1 P1  W= 1.08U L= 0.12U
MP4 8 18 7 1 P1  W= 0.36U L= 0.12U
MP5 1 19 8 1 P1  W= 0.36U L= 0.12U
MP6 9 19 1 1 P1  W= 0.36U L= 0.12U
MP7 1 18 9 1 P1  W= 0.36U L= 0.12U
MP8 7 20 9 1 P1  W= 0.36U L= 0.12U
*
C2 1 0 10.977fF
C3 3 0  1.897fF
C5 5 0  1.548fF
C6 6 0  2.147fF
C7 7 0  1.394fF
C8 8 0  0.073fF
C9 9 0  0.322fF
C10 10 0  0.253fF
C11 11 0  0.253fF
C12 12 0  0.358fF
C13 13 0  0.336fF
C14 14 0  0.077fF
C15 15 0  0.077fF
C16 16 0  0.057fF
C17 17 0  0.244fF
C18 18 0  1.161fF
C19 19 0  1.210fF
C20 20 0  0.999fF
C21 21 0  1.210fF
*
* Extra RLC
*
Cadd1 5 0 0.1pF
Cadd2 3 0 0.1pF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.TRAN 0.30PS 10.00N
.PROBE
.END
