CIRCUIT F:\CONTROLLO VERSIONE\MICRO\MicroA\Progetti_Microwind\MicroA_Capello.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
Va0 18 0 PULSE(0.00 1.20 0.50N 0.02N 0.02N 0.48N 1.00N)
Vc0 19 0 PULSE(0.00 1.20 2.50N 0.02N 0.02N 1.98N 4.00N)
Vclock 20 0 PULSE(0.00 1.20 0.23N 0.02N 0.02N 0.23N 0.50N)
Vb0 21 0 PULSE(0.00 1.20 1.50N 0.02N 0.02N 0.98N 2.00N)
*
* List of nodes
* "CARRY" corresponds to n°4
* "N5" corresponds to n°5
* "SUM" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* "N9" corresponds to n°9
* "a0" corresponds to n°18
* "c0" corresponds to n°19
* "clock" corresponds to n°20
* "b0" corresponds to n°21
*
* MOS devices
MN1 5 21 14 0 N1  W= 0.24U L= 0.12U
MN2 15 21 13 0 N1  W= 0.36U L= 0.12U
MN3 14 19 5 0 N1  W= 0.24U L= 0.12U
MN4 13 19 5 0 N1  W= 0.36U L= 0.12U
MN5 0 20 12 0 N1  W= 0.24U L= 0.12U
MN6 0 5 11 0 N1  W= 0.72U L= 0.12U
MN7 11 20 6 0 N1  W= 0.72U L= 0.12U
MN8 0 7 10 0 N1  W= 0.72U L= 0.12U
MN9 10 20 4 0 N1  W= 0.72U L= 0.12U
MN10 12 18 15 0 N1  W= 0.36U L= 0.12U
MN11 14 18 5 0 N1  W= 0.24U L= 0.12U
MN12 14 7 12 0 N1  W= 0.36U L= 0.12U
MN13 16 19 7 0 N1  W= 0.24U L= 0.12U
MN14 16 21 0 0 N1  W= 0.24U L= 0.12U
MN15 17 21 7 0 N1  W= 0.24U L= 0.12U
MN16 0 18 16 0 N1  W= 0.24U L= 0.12U
MN17 0 18 17 0 N1  W= 0.24U L= 0.12U
MP1 4 7 1 1 P1  W= 1.08U L= 0.12U
MP2 1 20 5 1 P1  W= 0.36U L= 0.12U
MP3 6 5 1 1 P1  W= 1.08U L= 0.12U
MP4 8 19 7 1 P1  W= 0.36U L= 0.12U
MP5 8 21 1 1 P1  W= 0.36U L= 0.12U
MP6 9 21 7 1 P1  W= 0.36U L= 0.12U
MP7 1 18 9 1 P1  W= 0.36U L= 0.12U
MP8 1 18 8 1 P1  W= 0.36U L= 0.12U
*
C2 1 0  6.096fF
C4 4 0  0.686fF
C5 5 0  0.975fF
C6 6 0  0.670fF
C7 7 0  1.254fF
C8 8 0  0.319fF
C9 9 0  0.073fF
C10 10 0  0.135fF
C11 11 0  0.135fF
C12 12 0  0.319fF
C13 13 0  0.077fF
C14 14 0  0.442fF
C15 15 0  0.077fF
C16 16 0  0.273fF
C17 17 0  0.057fF
C18 18 0  0.999fF
C19 19 0  1.045fF
C20 20 0  1.051fF
C21 21 0  1.054fF
*
* Extra RLC
*
Cadd1 4 0 0.1pF
Cadd2 6 0 0.1pF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.TRAN 0.30PS 10.00N
.PROBE
.END
