CIRCUIT F:\CONTROLLO VERSIONE\MICROA\Progetti_Microwind\full-adder.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
Vb0 18 0 PULSE(0.00 1.20 0.98N 0.02N 0.04N 0.97N 2.01N)
Vc0 19 0 PULSE(0.00 1.20 1.97N 0.03N 0.02N 1.98N 4.00N)
Va0 20 0 PULSE(0.00 1.20 0.48N 0.02N 0.02N 0.48N 1.00N)
Vclock 21 0 PULSE(0.00 1.20 0.23N 0.02N 0.02N 0.23N 0.50N)
*
* List of nodes
* "sum0" corresponds to n°4
* "carry" corresponds to n°5
* "N6" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* "N9" corresponds to n°9
* "b0" corresponds to n°18
* "c0" corresponds to n°19
* "a0" corresponds to n°20
* "clock" corresponds to n°21
*
* MOS devices
MN1 15 8 14 0 N1  W= 1.38U L= 0.12U
MN2 14 21 0 0 N1  W= 1.38U L= 0.12U
MN3 14 18 13 0 N1  W= 1.38U L= 0.12U
MN4 13 20 12 0 N1  W= 1.38U L= 0.12U
MN5 12 19 6 0 N1  W= 1.38U L= 0.12U
MN6 5 21 11 0 N1  W= 1.38U L= 0.12U
MN7 11 8 0 0 N1  W= 1.38U L= 0.12U
MN8 0 6 10 0 N1  W= 1.38U L= 0.12U
MN9 10 21 4 0 N1  W= 1.38U L= 0.12U
MN10 15 18 6 0 N1  W= 0.72U L= 0.12U
MN11 6 20 15 0 N1  W= 0.72U L= 0.12U
MN12 15 19 6 0 N1  W= 0.72U L= 0.12U
MN13 16 20 8 0 N1  W= 0.48U L= 0.12U
MN14 0 18 16 0 N1  W= 0.48U L= 0.12U
MN15 17 19 8 0 N1  W= 0.48U L= 0.12U
MN16 0 20 17 0 N1  W= 0.48U L= 0.12U
MN17 17 18 0 0 N1  W= 0.48U L= 0.12U
MP1 4 6 1 1 P1  W= 3.90U L= 0.12U
MP2 5 8 1 1 P1  W= 1.68U L= 0.12U
MP3 6 21 1 1 P1  W= 0.72U L= 0.12U
MP4 7 18 1 1 P1  W= 0.72U L= 0.12U
MP5 8 20 7 1 P1  W= 0.72U L= 0.12U
MP6 1 18 9 1 P1  W= 0.72U L= 0.12U
MP7 9 20 1 1 P1  W= 0.72U L= 0.12U
MP8 8 19 9 1 P1  W= 0.72U L= 0.12U
*
C2 1 0 10.308fF
C4 4 0  1.445fF
C5 5 0  1.057fF
C6 6 0  1.807fF
C7 7 0  0.129fF
C8 8 0  1.689fF
C9 9 0  0.686fF
C10 10 0  0.243fF
C11 11 0  0.243fF
C12 12 0  0.243fF
C13 13 0  0.243fF
C14 14 0  0.888fF
C15 15 0  0.905fF
C16 16 0  0.096fF
C17 17 0  0.362fF
C18 18 0  1.601fF
C19 19 0  1.454fF
C20 20 0  1.328fF
C21 21 0  1.135fF
*
* Extra RLC
*
Cadd1 4 0 0.1pF
Cadd2 5 0 0.1pF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.TRAN 0.30PS 10.00N
.PROBE
.END
