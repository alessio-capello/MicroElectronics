CIRCUIT F:\CONTROLLO VERSIONE\MICROA\Progetti_Microwind\MicroA_Morgillo_INGRESSI_ANDRE.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
Va0 18 0 PULSE(0.00 1.20 0.48N 0.02N 0.02N 0.48N 1.00N)
Vclock 19 0 PULSE(0.00 1.20 0.23N 0.02N 0.02N 0.23N 0.50N)
Vc0 20 0 PULSE(0.00 1.20 1.97N 0.03N 0.02N 1.98N 4.00N)
Vb0 21 0 PULSE(0.00 1.20 0.98N 0.02N 0.04N 0.97N 2.01N)
*
* List of nodes
* "SUM" corresponds to n°4
* "CARRY" corresponds to n°5
* "N6" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* "N9" corresponds to n°9
* "a0" corresponds to n°18
* "clock" corresponds to n°19
* "c0" corresponds to n°20
* "b0" corresponds to n°21
*
* MOS devices
MN1 13 21 6 0 N1  W= 0.24U L= 0.12U
MN2 15 21 14 0 N1  W= 0.36U L= 0.12U
MN3 14 20 6 0 N1  W= 0.36U L= 0.12U
MN4 6 20 13 0 N1  W= 0.24U L= 0.12U
MN5 13 7 12 0 N1  W= 0.24U L= 0.12U
MN6 0 19 11 0 N1  W= 0.72U L= 0.12U
MN7 11 7 5 0 N1  W= 0.72U L= 0.12U
MN8 0 19 10 0 N1  W= 0.72U L= 0.12U
MN9 10 6 4 0 N1  W= 0.72U L= 0.12U
MN10 12 18 15 0 N1  W= 0.36U L= 0.12U
MN11 6 18 13 0 N1  W= 0.24U L= 0.12U
MN12 0 19 12 0 N1  W= 0.36U L= 0.12U
MN13 16 18 7 0 N1  W= 0.24U L= 0.12U
MN14 0 21 16 0 N1  W= 0.24U L= 0.12U
MN15 17 21 0 0 N1  W= 0.24U L= 0.12U
MN16 0 18 17 0 N1  W= 0.24U L= 0.12U
MN17 7 20 17 0 N1  W= 0.24U L= 0.12U
MP1 4 6 1 1 P1  W= 2.22U L= 0.12U
MP2 5 7 1 1 P1  W= 2.16U L= 0.12U
MP3 6 19 1 1 P1  W= 0.36U L= 0.12U
MP4 8 18 7 1 P1  W= 0.36U L= 0.12U
MP5 1 21 8 1 P1  W= 0.36U L= 0.12U
MP6 9 21 1 1 P1  W= 0.36U L= 0.12U
MP7 1 18 9 1 P1  W= 0.36U L= 0.12U
MP8 7 20 9 1 P1  W= 0.36U L= 0.12U
*
C2 1 0  6.394fF
C4 4 0  0.877fF
C5 5 0  0.843fF
C6 6 0  1.401fF
C7 7 0  1.253fF
C8 8 0  0.073fF
C9 9 0  0.322fF
C10 10 0  0.135fF
C11 11 0  0.135fF
C12 12 0  0.330fF
C13 13 0  0.270fF
C14 14 0  0.077fF
C15 15 0  0.077fF
C16 16 0  0.057fF
C17 17 0  0.244fF
C18 18 0  1.158fF
C19 19 0  1.149fF
C20 20 0  0.996fF
C21 21 0  1.207fF
*
* Extra RLC
*
Cadd1 5 0 0.1pF
Cadd2 4 0 0.1pF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.TRAN 0.30PS 10.00N
.PROBE
.END
